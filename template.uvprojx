# Keil uVision project template.uvprojx, settings and files
target ZET6 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ZET6 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\Startup;.\Lib\inc;.\Lib\src;.\User;.\Basic\adc;.\Basic\delay;.\Basic\rtc;.\Basic\spi;.\Basic\sys;.\Basic\i2c;.\Basic\usart;.\Basic\pwm;.\Basic\pid;.\Hardware\KEY;.\Hardware\LED;.\Hardware\L298N;.\Hardware\NRF24L01;.\Hardware\OLED2420;.\Hardware\TEMP_SENSOR;.\Hardware\L298N;.\Hardware\MPU6050;.\Hardware\MPU6050\eMPL;.\Hardware\VL53L0X\platform;.\Hardware\VL53L0X\demo;.\Hardware\VL53L0X\core;.\Hardware\HC_SR04;.\Hardware\ESP8266
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ./Startup/: startup_stm32f10x_hd.s
  group Lib
    ./Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Basic
    ./Basic/adc/: adc.c
    ./Basic/delay/: delay.c
    ./Basic/rtc/: rtc.c
    ./Basic/spi/: spi.c
    ./Basic/sys/: sys.c
    ./Basic/usart/: usart.c
    ./Basic/i2c/: myiic.c
    ./Basic/pwm/: pwm.c
    ./Basic/pid/: pid.c
  group Hardware
    ./Hardware/LED/: led.c
    ./Hardware/NRF24L01/: 24l01.c
    ./Hardware/OLED2420/: oled2420.c
    ./Hardware/KEY/: key.c
    ./Hardware/TEMP_SENSOR/: temp_sensor.c
    ./Hardware/L298N/: l298n.c
    ./Hardware/MPU6050/: mpu6050.c
    ./Hardware/VL53L0X/demo/: vl53l0x.c
    ./Hardware/HC_SR04/: hc_sr04.c
  group inv_mpu_driver
    ./Hardware/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group VL53L0X_Core
    ./Hardware/VL53L0X/core/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
  group VL53L0X_Platform
    ./Hardware/VL53L0X/platform/: vl53l0x_i2c.c vl53l0x_platform.c
    ./Hardware/VL53L0X/demo/: vl53l0x_cali.c vl53l0x_gen.c
  group ESP_8266
    ./Hardware/ESP8266/: esp8266_timer.c esp8266.c
  group User
    ./User/: main.c stm32f10x_it.c
